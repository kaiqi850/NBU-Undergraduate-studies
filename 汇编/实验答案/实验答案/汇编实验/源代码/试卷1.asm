DATAS SEGMENT
    ;此处输入数据段代码  
DATAS ENDS

STACKS SEGMENT
    ;此处输入堆栈段代码
STACKS ENDS

CODES SEGMENT
    ASSUME CS:CODES,DS:DATAS,SS:STACKS
START:
    MOV AX,DATAS
    MOV DS,AX
    ;此处输入代码段代码
    
    MOV AX,4000H
    MOV DS,AX
    
    MOV SI,00H
    MOV DI,00H
    MOV CX,3000H
    
ALOOP:
	MOV byte ptr [SI],55H
	INC SI
	LOOP ALOOP
	
	MOV SI,00H
	MOV CX,3000H

BLOOP:
	MOV AL,[SI]
	INC SI
	CMP AL,55H
	JNE ERR
	LOOP BLOOP
	JMP SUC
	
ERR:
	MOV AL,81H
	MOV AH,4CH
	INT 21H
	
SUC:
	MOV AL,7EH
	MOV AH,4CH
	INT 21H
    
    
    MOV AH,4CH
    INT 21H
CODES ENDS
    END START



